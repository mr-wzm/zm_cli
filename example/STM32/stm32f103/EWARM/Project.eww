<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\zm_cli.ewp</path>
  </project>
  <batchBuild />
</workspace>
